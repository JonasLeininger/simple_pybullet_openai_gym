Commit message: implement orbiting rewardObject

File: box.urdf (robot description, URDF)
Before this commit: robot simplebox, 2 links, 1 joints
Joints:
- joint boxlink: origin xyz=.5 0.5 0.5 rpy=0 0 0 -> xyz=0 0 0.15 rpy=0 0 0
